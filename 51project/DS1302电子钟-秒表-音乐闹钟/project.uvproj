# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c DS1302.c DELAY.c DELAY.h DS1302.h Timer0_Init.c Timer0_Init.h Nixie.h Nixie.c matrixkey.c matrixkey.h Music.c Music.h Timer1_Init.c Timer1_Init.h AT24C02.c AT24C02.h I2C.c I2C.h
